# Keil uVision project AT32F403ACGT7_WorkBench_final.uvprojx, settings and files
target AT32F403ACGT7_WorkBench_final (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: -AT32F403ACGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.4
  cpu: IRAM(0x20000000,0x6000000) IROM(0x08000000,0x40000000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ACGT7_WorkBench_final +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403ACGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c ads131m0x.c ads131m0x_function.c DA16600.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_debug.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_spi.c at32f403a_407_tmr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
